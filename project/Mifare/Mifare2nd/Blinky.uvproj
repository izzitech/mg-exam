# Keil uVision project Blinky.uvproj, settings and files
target LPC122x RAM (ARM-ADS)
  device: LPC1227/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x10000000 size 0x1800
  memory RVCT9: RAM 0x10001800 size 0x800
  group StartUp
    ./: startup_LPC122x.s system_LPC122x.c int.s
  group Source Files
    ./: Retarget.c Serial.c IRQ.c Blinky.c SSP.c gpio.c
    ./Mifare/: mfrc531.c iso14443a.c
  group Documentation
    ./: Abstract.txt
target LPC122x Flash (ARM-ADS)
  device: LPC1227/301 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: .\Mifare;..\Blinky
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x2000
